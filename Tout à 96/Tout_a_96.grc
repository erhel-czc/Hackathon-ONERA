options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '10'
    samples_per_second: '32000'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self):  
              gr.sync_block.__init__(
                  self,
                  name='Test',  
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.signal = []
              self.count = 0

          def work(self, input_items, output_items):
              self.signal = np.concatenate((self.signal,input_items[0]),axis=0)
              if len(self.signal) >= 4096:
                  self.count+=1
                  if self.count==100:
                      output_items[0][:] = self.signal[:4096]
                      self.signal = self.signal[4096:]
                      print(output_items[0])
                  else:
                      output_items[0] = []
              else :
                  output_items[0] = []
              return len(output_items[0])
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self):  
              gr.sync_block.__init__(
                  self,
                  name='Tiago Print Block',  
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              print(len(output_items[0]))
              print(output_items[0])
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', epy_block_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
